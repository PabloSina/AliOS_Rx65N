# IAR project STM32L073RZTx.ewp, settings and files
configuration STM32L073RZTx (ARM, debug)
  General.OGChipSelectEditMenu: STM32L073RZ ST STM32L073RZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L073xx; SYSINFO_OS_VERSION=\"APP-1.0.0\"; SYSINFO_PRODUCT_MODEL=\"ALI_AOS_STM32L073RZTx\"; SYSINFO_DEVICE_NAME=\"STM32L073RZTx\"; SYSINFO_KERNEL_VERSION=\"AOS-R-1.0.1\"; SYSINFO_APP_VERSION=\"APP-1.0.0\"; STDIO_UART=0; CONFIG_NO_TCPIP; RHINO_CONFIG_TICK_TASK=0; CONFIG_AOS_KV_MULTIPTN_MODE; CONFIG_AOS_KV_PTN=6; CONFIG_AOS_KV_SECOND_PTN=7; CONFIG_AOS_KV_PTN_SIZE=4096; CONFIG_AOS_KV_BUFFER_SIZE=8192; __BSD_VISIBLE
  ICCARM.CCIncludePath2: ..\..\..\..\include; ..\..\..\..\kernel\rhino\core\include; ..\..\..\..\platform\arch\arm\armv6m\iccarm\m0; ..\..\..\..\platform\mcu\stm32l0xx\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\platform\mcu\stm32l0xx\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy; ..\..\..\..\platform\mcu\stm32l0xx\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\platform\mcu\stm32l0xx\Drivers\CMSIS\Include; ..\..\..\..\platform\mcu\stm32l0xx\src\STM32L073RZ-Nucleo\aos_rhino; ..\..\..\..\include\hal; ..\..\..\..\kernel\vcall\aos; D:\git\alios_things_kernel\utility\libc\compilers\iar; ..\..\..\..\kernel\modules\fs\kv\include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32L073RZTx.out
  ILINK.IlinkIcfFile: stm32l073xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group AOS/Arch
    ../../../../platform/arch/arm/armv6m/iccarm/m0/: port_c.c port_s.S
  group AOS/fs\kv
    ../../../../kernel/modules/fs/kv/: kvmgr.c
  group AOS/Kernel
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_fifo.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_obj_set.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_trace.c k_workqueue.c
  group Application
    ../../../../platform/mcu/stm32l0xx/src/STM32L073RZ-Nucleo/aos_rhino/: aos_rhino_kv.c
    ../../../../platform/mcu/stm32l0xx/src/STM32L073RZ-Nucleo/hal/: flash_port.c
    ../../../../platform/mcu/stm32l0xx/aos/: soc_impl.c
    ../../../../platform/mcu/stm32l0xx/src/STM32L073RZ-Nucleo/helloworld/: soc_init.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../platform/mcu/stm32l0xx/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Drivers/SYSTEM
    ../../../../platform/mcu/stm32l0xx/src/STM32L073RZ-Nucleo/: startup_stm32l073xx_iar.s
    ../../../../platform/mcu/stm32l0xx/src/STM32L073RZ-Nucleo/helloworld/: system_stm32l0xx.c
  group Example
    ../../../../board/stm32l073rz-nucleo/: board.c
    ../../../../example/rhinorun/: rhinorun.c
