# IAR project basic.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenHugeHeapSize: 0
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 800
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: ..\..\..\kernel\rhino\core\include; ..\..\..\platform\mcu\r5f100lea; ..\..\..\example\r5f_test; ..\..\..\platform\arch\rl78
  ARL78.AsmIncludePath: ..\..\..\platform\arch\rl78
  OBJCOPY.OOCOutputFile: templproj.srec
  ILINK.IlinkOutputFile: basic.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  General.GenDeviceSelect: UnspecifiedRL78_2 RL78 core S3 - Unspecified
  General.GenStackSize: 128
  ICCRL78.CCDefines: NDEBUG
  group (top)
    ../../../example/r5f_test/: test_r5f.c
  group bsp
    ../../../platform/mcu/r5f100lea/: bsp.c bsp_vect_a.asm soc_impl.c
  group kernel
    ../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_fifo.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_obj_set.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_trace.c k_workqueue.c
  group port
    ../../../platform/arch/rl78/: port_c.c port_cpu.s
